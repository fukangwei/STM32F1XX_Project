# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\CORE;..\..\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\User;.\HARDWARE\SPI;.\HARDWARE\ENC28J60;.\HARDWARE\TIMER;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include\lwip;..\..\LWIP\lwip-1.4.1\src\include\netif;..\..\LWIP\lwip_app;..\..\LWIP\lwip_app\tcp_client;.\HARDWARE\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group USER
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/ENC28J60/: enc28j60.c
    ./HARDWARE/TIMER/: timerx.c
    ./HARDWARE/KEY/: key.c
  group LWIP_API
    ../../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_CORE
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_IPv4
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_NETIF
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group LWIP_ARCH
    ../../LWIP/lwip_app/arch/: sys_arch.c
  group LWIP_APP
    ../../LWIP/lwip_app/tcp_client/: tcp_client.c
